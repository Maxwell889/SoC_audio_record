# Keil uVision project cnasic_sleep.uvprojx, settings and files
target cnasic_sleep (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: cnasic_sleep +hex
  AfterMake: fromelf.exe --vhx --32x1 --output=.\output\outfile.bin .\objects\cnasic_sleep.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\App\inc;..\..\Chip\CMSIS;..\..\Chip\Hal_lib\inc;..\..\Chip\Startup\inc
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x8000 size 0x8000
  link misc: --entry Reset_Handler
  group App
    ../../App/: delay.c main.c
  group Hal_lib
    ../../Chip/Hal_lib/: gpio.c mem.c nvic.c timer.c usart.c
  group Startup
    ../../Chip/Startup/keil/: cnasic_soc.s
